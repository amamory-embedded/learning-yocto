require recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL_append = " vim nano htop mc"

