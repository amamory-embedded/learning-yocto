# source : https://github.com/rikonek/yocto/blob/3d5be339f01e2eb20caea0ee4ed01d1cc3e838be/README.md
FILESEXTRAPATHS_prepend := "${THISDIR}:"
